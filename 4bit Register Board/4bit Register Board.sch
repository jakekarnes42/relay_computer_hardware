File: 4bit Register Board/4bit Register Board.sch (EAGLE design)
At the start: 9 parts

Commit message: Adding TMP registers back into Register Board
Connections:
- net N$17 renamed LOAD_CCR
